<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>template</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>app</name>
    <group>
      <name>serial-shell</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\apps\serial-shell\serial-shell.c</name>
      </file>
    </group>
    <group>
      <name>shell</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\apps\shell\shell.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>core</name>
    <group>
      <name>dev</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\dev\leds.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\dev\nullradio.c</name>
      </file>
    </group>
    <group>
      <name>lib</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\lib\assert.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\lib\crc16.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\lib\gcr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\lib\ifft.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\lib\list.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\lib\me.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\lib\me_tabs.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\lib\memb.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\lib\mmem.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\lib\petsciiconv.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\lib\print-stats.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\lib\random.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\lib\ringbuf.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\lib\sensors.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\lib\settings.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\lib\strncasecmp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\lib\trickle-timer.c</name>
      </file>
    </group>
    <group>
      <name>net</name>
      <group>
        <name>mac</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\core\net\mac\contikimac.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\core\net\mac\csma.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\core\net\mac\cxmac.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\core\net\mac\frame802154.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\core\net\mac\framer-802154.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\core\net\mac\framer-nullmac.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\core\net\mac\lpp.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\core\net\mac\mac.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\core\net\mac\nullmac.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\core\net\mac\nullrdc-noframer.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\core\net\mac\nullrdc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\core\net\mac\phase.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\core\net\mac\sicslowmac.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\core\net\mac\xmac.c</name>
        </file>
      </group>
      <group>
        <name>rime</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\core\net\rime\rimeaddr.c</name>
        </file>
      </group>
      <group>
        <name>rpl</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\core\net\rpl\rpl-dag.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\core\net\rpl\rpl-ext-header.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\core\net\rpl\rpl-icmp6.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\core\net\rpl\rpl-mrhof.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\core\net\rpl\rpl-of0.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\core\net\rpl\rpl-timers.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\core\net\rpl\rpl.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\net\dhcpc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\net\hc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\net\nbr-table.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\net\netstack.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\net\packetbuf.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\net\packetqueue.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\net\psock.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\net\queuebuf.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\net\rawpacket-udp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\net\resolv.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\net\sicslowpan.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\net\simple-udp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\net\slipdev.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\net\tcpdump.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\net\tcpip.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\net\uaodv-rt.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\net\uaodv.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\net\uip-debug.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\net\uip-ds6-nbr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\net\uip-ds6-route.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\net\uip-ds6.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\net\uip-fw-drv.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\net\uip-fw.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\net\uip-icmp6.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\net\uip-nd6.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\net\uip-neighbor.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\net\uip-over-mesh.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\net\uip-packetqueue.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\net\uip-split.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\net\uip-udp-packet.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\net\uip.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\net\uip6.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\net\uip_arp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\net\uiplib.c</name>
      </file>
    </group>
    <group>
      <name>sys</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\sys\arg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\sys\autostart.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\sys\compower.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\sys\ctimer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\sys\energest.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\sys\etimer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\sys\mt.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\sys\process.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\sys\procinit.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\sys\profile-aggregates.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\sys\profile.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\sys\rtimer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\sys\stimer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\sys\timer.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>zonesion</name>
    <group>
      <name>cpu</name>
      <group>
        <name>stm32f10x</name>
        <group>
          <name>cmsis</name>
          <group>
            <name>cm3</name>
            <group>
              <name>core</name>
              <file>
                <name>$PROJ_DIR$\..\..\common\cpu\stm32f10x\Libraries\CMSIS\CM3\CoreSupport\core_cm3.c</name>
              </file>
            </group>
            <group>
              <name>stm32f10x-start</name>
              <file>
                <name>$PROJ_DIR$\..\..\common\cpu\stm32f10x\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\iar\startup_stm32f10x_md.s</name>
              </file>
            </group>
          </group>
        </group>
        <group>
          <name>STM32F10x_StdPeriph_Driver</name>
          <file>
            <name>$PROJ_DIR$\..\..\common\cpu\stm32f10x\Libraries\STM32F10x_StdPeriph_Driver\src\misc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\common\cpu\stm32f10x\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_adc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\common\cpu\stm32f10x\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_bkp.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\common\cpu\stm32f10x\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_can.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\common\cpu\stm32f10x\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_cec.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\common\cpu\stm32f10x\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_crc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\common\cpu\stm32f10x\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_dac.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\common\cpu\stm32f10x\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_dbgmcu.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\common\cpu\stm32f10x\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_dma.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\common\cpu\stm32f10x\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_exti.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\common\cpu\stm32f10x\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_flash.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\common\cpu\stm32f10x\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_fsmc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\common\cpu\stm32f10x\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_gpio.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\common\cpu\stm32f10x\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_i2c.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\common\cpu\stm32f10x\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_iwdg.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\common\cpu\stm32f10x\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_pwr.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\common\cpu\stm32f10x\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_rcc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\common\cpu\stm32f10x\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_rtc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\common\cpu\stm32f10x\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_sdio.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\common\cpu\stm32f10x\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_spi.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\common\cpu\stm32f10x\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_tim.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\common\cpu\stm32f10x\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_usart.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\common\cpu\stm32f10x\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_wwdg.c</name>
          </file>
        </group>
        <file>
          <name>$PROJ_DIR$\..\..\common\cpu\stm32f10x\clock.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\common\cpu\stm32f10x\rtimer-arch.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\common\cpu\stm32f10x\sip2.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\common\cpu\stm32f10x\system_stm32f10x.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\common\cpu\stm32f10x\uart1.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\common\cpu\stm32f10x\uart2.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\common\cpu\stm32f10x\uart3.c</name>
        </file>
      </group>
    </group>
    <group>
      <name>LTE</name>
      <group>
        <name>app</name>
        <file>
          <name>$PROJ_DIR$\..\..\common\app\at-uart.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\common\app\at.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\common\app\zhiyun.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\common\app\zxbee-inf.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\common\app\zxbee-sys-command.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\common\app\zxbee.c</name>
        </file>
      </group>
      <group>
        <name>dev</name>
        <file>
          <name>$PROJ_DIR$\..\..\common\dev\config.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\common\dev\debug.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\common\dev\key.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\common\dev\leds-arch.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\common\dev\lte-ec20.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\common\dev\lte-inf.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\common\dev\lte-tcp.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\common\dev\relay.c</name>
        </file>
      </group>
      <group>
        <name>sensor</name>
        <file>
          <name>$PROJ_DIR$\..\src\autoapps.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\sensor.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\sensor.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\UserAt.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\common\contiki-conf.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\common\contiki-main.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\readme.txt</name>
      </file>
    </group>
  </group>
</project>


